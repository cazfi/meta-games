require freeciv.inc
LICENSE = "GPLv2"

PR = "r0"

SRC_URI[md5sum] = "90d2c95a74398616b385bf6dbd1f813e"
SRC_URI[sha256sum] = "15d886759a13a546985bf3e6824ca2dfbefb568f12d85ac63da06ff013d91f7a"

LIC_FILES_CHKSUM = "file://COPYING;md5=0636e73ff0215e8d672dc4c32c317bb3"

acpaths = "-I ${S}/m4 -I ${S}/dependencies/m4"

