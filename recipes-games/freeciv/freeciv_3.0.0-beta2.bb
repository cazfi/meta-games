
require freeciv.inc

DEFAULT_PREFERENCE = "-1"

SRC_URI += "\
${SOURCEFORGE_MIRROR}/freeciv/freeciv-${PV}.tar.xz \
"

SRC_URI[sha256sum] = "9f44dc28068b239c18bda68192ddb27622030880f8ab9c17f777eac28391269e"
