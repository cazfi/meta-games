require freeciv.inc

PR = "r0"

SRC_URI += "${SOURCEFORGE_MIRROR}/freeciv/freeciv-${PV}.tar.bz2"

SRC_URI[md5sum] = "2a49c417ffedd54cf648adf1ddf707a9"
SRC_URI[sha256sum] = "084c10c50c06166177c9864b5610eaf36dca3808e3d3a7da8ef7ae927d56c41c"
