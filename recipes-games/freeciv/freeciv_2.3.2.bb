require freeciv.inc

PR = "r1"

SRC_URI += "${SOURCEFORGE_MIRROR}/freeciv/freeciv-${PV}.tar.gz"

SRC_URI[md5sum] = "90d2c95a74398616b385bf6dbd1f813e"
SRC_URI[sha256sum] = "15d886759a13a546985bf3e6824ca2dfbefb568f12d85ac63da06ff013d91f7a"
