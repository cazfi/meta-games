FREECIV_GUI = "gtk2"

require freeciv.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=0636e73ff0215e8d672dc4c32c317bb3"

SRC_URI[md5sum] = "a5483c9e4ffa62dd17b54404fe06ceb0"
SRC_URI[sha256sum] = "f1537787f505b6aa94e99185879e235ad3a778e6bbdef830d256dbbb67384de6"
