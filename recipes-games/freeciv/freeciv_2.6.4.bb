
require freeciv.inc

SRC_URI += "\
${SOURCEFORGE_MIRROR}/freeciv/freeciv-${PV}.tar.bz2 \
"

SRC_URI[sha256sum] = "40db957766acbd49c5af15afd1711da996b6681be7abee3352c5f2539c10c1ce"
