
require freeciv.inc

DEFAULT_PREFERENCE = "-1"

SRC_URI += "\
${SOURCEFORGE_MIRROR}/freeciv/freeciv-${PV}.tar.xz \
"

SRC_URI[sha256sum] = "d9f66d39c04aa6c8fda5fe625395054bdd6bc5edeb5705cc926ebc8b3c05d90d"
