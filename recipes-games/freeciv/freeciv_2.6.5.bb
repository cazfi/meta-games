
require freeciv.inc

SRC_URI += "\
${SOURCEFORGE_MIRROR}/freeciv/freeciv-${PV}.tar.bz2 \
"

SRC_URI[sha256sum] = "2e64e1c74dae12acb17bbf5daa980efc7e9fd57820afed5135319ca95291ec59"
