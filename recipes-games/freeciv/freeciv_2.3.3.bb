require freeciv.inc

PR = "r1"

SRC_URI += "${SOURCEFORGE_MIRROR}/freeciv/freeciv-${PV}.tar.bz2"

SRC_URI[md5sum] = "f564739c04376a87ccb8e5369ebfc519"
SRC_URI[sha256sum] = "fc88a8330fa1f30676e775bbdc31c57e07792a45b9b7c31f3a27728351b90258"
