
require freeciv.inc

DEFAULT_PREFERENCE = "-1"

SRC_URI += "\
${SOURCEFORGE_MIRROR}/freeciv/freeciv-${PV}.tar.xz \
"

SRC_URI[sha256sum] = "dd36e9f89969db6da3e8218967ad8fa32c4d0c31f91bf422902c669d69dc94ad"
