
require freeciv.inc

DEFAULT_PREFERENCE = "-1"

SRC_URI += "\
${SOURCEFORGE_MIRROR}/freeciv/freeciv-${PV}.tar.xz \
"

SRC_URI[sha256sum] = "53bd26480126ed4ea0bf62af0af522eba13d592e29e430f50fd5e52819196464"
